# Keil uVision project Stmarlin.uvprojx, settings and files
target 3DPrinter_Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STMarlin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Chip\chip;..\Chip\delay;..\Chip\usart;..\Chip\timer;..\Chip\adc;..\Chip\spi;..\Board\flash;..\Stmarlin\Gcode;..\Stmarlin\MainLib;..\Stmarlin\SerialLib;..\Stmarlin\ConfigurationLib;..\Stmarlin\StepperLib;..\Stmarlin\TempretureLib;..\Stmarlin\PlanMotionLib;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STFWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CHIP
    ../Chip/chip/: chip.c
    ../Chip/delay/: delay.c
    ../Chip/usart/: usart.c
    ../Chip/timer/: timer.c
    ../Chip/adc/: adc.c
    ../Chip/spi/: spi.c
  group BOARD
    ../Board/flash/: flash.c
  group STMARLIN
    ../Stmarlin/MainLib/: stmarlin.c
    ../Stmarlin/ConfigurationLib/: ConfigurationStore.c
    ../Stmarlin/PlanMotionLib/: motion_control.c planner.c
    ../Stmarlin/SerialLib/: serial.c
    ../Stmarlin/StepperLib/: stepper.c
    ../Stmarlin/TempretureLib/: temperature.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group DOC
    ../Doc/: readme.txt
target 3DPrinter_Release (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STMarlin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
